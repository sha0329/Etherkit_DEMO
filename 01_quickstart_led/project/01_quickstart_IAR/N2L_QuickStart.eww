<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\N2L_QuickStart.ewp</path>
    </project>
    <batchBuild/>
</workspace>
